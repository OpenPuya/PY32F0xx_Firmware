# IAR project Project.ewp, settings and files
configuration PY32F030-STK (ARM, debug)
  General.OGChipSelectEditMenu: PY32F030x8 Puya PY32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; PY32F030x8
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\BSP\PY32F030xx_Start_Kit; ..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f030x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/PY32F030xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32F030xx_Start_Kit/: py32f030xx_ll_Start_Kit.c
  group Drivers/CMSIS
    ../Src/: system_py32f0xx.c
  group Drivers/PY32F0xx_HAL_Driver
    ../../../../../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_ll_dma.c py32f0xx_ll_exti.c py32f0xx_ll_gpio.c py32f0xx_ll_pwr.c py32f0xx_ll_rcc.c py32f0xx_ll_utils.c
  group Example/EWARM
    ./: startup_py32f030xx.s
  group Example/User
    ../Src/: main.c py32f0xx_it.c
